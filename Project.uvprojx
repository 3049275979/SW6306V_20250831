# Keil uVision project Project.uvprojx, settings and files
target PY32F030x4_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F030x4
  c include: ..\Inc;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ./: startup_py32f030xx.s
    ./Drivers/Src/: system_py32f0xx.c
  group Application
    ./: py32f0xx_it.c main.c
    ./Applications/: bsp_py32f030x6.c debounce_key.c
  group Drivers
    ./Drivers/Src/: py32f0xx_ll_adc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_tim.c py32f0xx_ll_utils.c py32f0xx_bsp_exti.c py32f0xx_bsp_gpio.c py32f0xx_bsp_i2c.c py32f0xx_bsp_pwr.c py32f0xx_bsp_rcc.c py32f0xx_bsp_tim.c py32f0xx_bsp_usart.c
  group OS
    ./coroOS/: coroOS.c
  group External
    ./Drivers/SW6306/: sw6306.c
  group LCD12864
    ./Drivers/LCD12864/: 12864oled_drv.c myspi_drv.c
    ./Drivers/: shtc3_drv.c ds3231_drv.c
  group Menu
    ./Menu/: menu.c
target PY32F030x6_Project (6140000::V6.14::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F030x6,USE_FULL_LL_DRIVER
  c misc: -Wno-invalid-source-encoding
  c include: .\;.\Inc;.\Drivers\Inc;.\coroOS;.\coroOS\pt1.4;.\Applications;.\Drivers\SW6306;.\Drivers\LCD12864;.\Menu;.\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target PY32F030x7_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x7 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F030x7
  c include: ..\Inc;..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x1800
target PY32F030x8_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F030x8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.4.0
